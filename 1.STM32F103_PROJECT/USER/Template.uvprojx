# Keil uVision project Template.uvprojx, settings and files
target Template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: fromelf --bin -output=..\OBJ\Template.bin ..\OBJ\Template.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;.\UserCode\Peripheral;.\UserCode\Modules\task;.\UserCode\Components\InfoTime;..\SystemView\Config;..\SystemView\SEGGER;..\SystemView\Sample\FreeRTOSV10.4;.\UserCode\Modules\upgrade;.\UserCode\Components\DataCheck;.\UserCode\Components\DataEncrypt;.\UserCode\Components\StoreManage;.\UserCode\Modules\ble;.\UserCode\Modules\ble\ATK_BLE03;.\UserCode\Components\InfoProtocol;.\UserCode\Modules\InfoComm;.\UserCode\Components\DebugLog;.\UserCode\Modules\button
  memory RVCT4: ROM 0x8006000 size 0x39800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group PERIPHERAL
    ./UserCode/Peripheral/: timer.c rtc.c iwdg.c stmflash.c spi.c led.c hw_gpio.c
  group FreeRTOS/CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group SystemView
    ../SystemView/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
    ../SystemView/Sample/FreeRTOSV10.4/Config/Cortex-M/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../SystemView/Sample/FreeRTOSV10.4/: SEGGER_SYSVIEW_FreeRTOS.c
  group COMP/InfoProtocol
    ./UserCode/Components/InfoProtocol/: bsp_protocol.c bsp_ymodem.c
  group COMP/InfoTime
    ./UserCode/Components/InfoTime/: bsp_time.c
  group COMP/DataCheck
    ./UserCode/Components/DataCheck/: bsp_crc.c bsp_md5.c
  group COMP/DataEncrypt
    ./UserCode/Components/DataEncrypt/: bsp_aes.c bsp_rsa.c
  group COMP/StoreManage
    ./UserCode/Components/StoreManage/: hw_w25qxx.c
  group COMP/log
    ./UserCode/Components/DebugLog/: app_log.c bsp_log.c
  group MODU/InfoComm
    ./UserCode/Modules/InfoComm/: app_comm.c bsp_comm.c
  group MODU/task
    ./UserCode/Modules/task/: bsp_task_events.c app_task.c
  group MODU/upgrade
    ./UserCode/Modules/upgrade/: bsp_upgrade.c app_upgrade.c
  group MODU/ble
    ./UserCode/Modules/ble/ATK_BLE03/: atk_ble03.c atk_ble03_uart.c
    ./UserCode/Modules/ble/: app_ble.c bsp_ble.c
  group MODU/button
    ./UserCode/Modules/button/: bsp_button.c app_button.c
