# Keil uVision project ble_app_simple_server.uvproj, settings and files
target ble_app_simple_server (6140000::V6.14::ARMCLANG)
  device: HS6621C.FPU HunterSun
  cpu: CLOCK(64000000) CPUTYPE("Cortex-M4") FPU2
  output: ble_app_simple_server
  AfterMake: fromelf.exe --bin --output "$L..\@L.bin" "#L"
  AfterMake: fromelf.exe -c --output "$L..\@L.dis" "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_LOG_OUTPUT CONFIG_RTOS
  c misc: @../../../lib/keil/armclang.via
  c include: ..\..\..\coroutine;..\..\..\include;..\..\..\main;..\..\..\hardware\sys;..\..\..\hardware\cmsis;..\..\..\hardware\cfg;..\..\..\hardware\peripheral;..\..\..\hardware\rw_port;..\..\..\hardware\patch;..\..\..\hardware\loader;..\..\..\hardware\mbr;..\..\..\stack\ip\ahi\api;..\..\..\stack\ip\hci\api;..\..\..\stack\ip\sch\api;..\..\..\stack\ip\em\api;..\..\..\stack\modules\aes\api;..\..\..\stack\modules\common\api;..\..\..\stack\modules\dbg\api;..\..\..\stack\modules\display\api;..\..\..\stack\modules\ecc_p256\api;..\..\..\stack\modules\h4tl\api;..\..\..\stack\modules\ke\api;..\..\..\stack\modules\nvds\api;..\..\..\stack\modules\rf\api;..\..\..\stack\modules\rwip\api;..\..\..\stack\modules\rwip\src;..\..\..\stack\plf\hs6621\arch;..\..\..\stack\plf\hs6621\reg;..\..\..\stack\ip\ble\hl\api;..\..\..\stack\ip\ble\hl\inc;..\..\..\stack\ip\ble\hl\src\rwble_hl;..\..\..\stack\ip\ble\ll\api;..\..\..\stack\ip\ble\ll\src;..\..\..\stack\ip\ble\mesh\api;..\..\..\stack\ip\ble\mesh\inc;..\..\..\stack\ip\ble\mesh\inc_al;..\..\..\stack\ip\ble\mesh\src\common\inc;..\..\..\stack\ip\ble\mesh\src\inc;..\..\..\stack\ip\ble\mesh\src\models;..\..\..\stack\ip\ble\mesh\src\models\inc;..\..\..\stack\ip\ble\mesh\src\models\src;..\..\..\stack\ip\ble\mesh\src\prf;..\..\..\stack\ip\ble\mesh\src\prf\inc;..\..\..\stack\ip\ble\profiles\anp;..\..\..\stack\ip\ble\profiles\bas;..\..\..\stack\ip\ble\profiles\bcs;..\..\..\stack\ip\ble\profiles\blp;..\..\..\stack\ip\ble\profiles\cpp;..\..\..\stack\ip\ble\profiles\cscp;..\..\..\stack\ip\ble\profiles\dis;..\..\..\stack\ip\ble\profiles\find;..\..\..\stack\ip\ble\profiles\glp;..\..\..\stack\ip\ble\profiles\hogp;..\..\..\stack\ip\ble\profiles\hrp;..\..\..\stack\ip\ble\profiles\htp;..\..\..\stack\ip\ble\profiles\lan;..\..\..\stack\ip\ble\profiles\pasp;..\..\..\stack\ip\ble\profiles\prox;..\..\..\stack\ip\ble\profiles\rscp;..\..\..\stack\ip\ble\profiles\scpp;..\..\..\stack\ip\ble\profiles\tip;..\..\..\stack\ip\ble\profiles\uds;..\..\..\stack\ip\ble\profiles\wscp;..\..\..\stack\ip\ble\profiles\anp\anpc\api;..\..\..\stack\ip\ble\profiles\anp\anps\api;..\..\..\stack\ip\ble\profiles\bas\basc\api;..\..\..\stack\ip\ble\profiles\bas\bass\api;..\..\..\stack\ip\ble\profiles\bcs\bcsc\api;..\..\..\stack\ip\ble\profiles\bcs\bcss\api;..\..\..\stack\ip\ble\profiles\blp\blpc\api;..\..\..\stack\ip\ble\profiles\blp\blps\api;..\..\..\stack\ip\ble\profiles\cpp\cppc\api;..\..\..\stack\ip\ble\profiles\cpp\cpps\api;..\..\..\stack\ip\ble\profiles\cscp\cscpc\api;..\..\..\stack\ip\ble\profiles\cscp\cscps\api;..\..\..\stack\ip\ble\profiles\dis\disc\api;..\..\..\stack\ip\ble\profiles\dis\diss\api;..\..\..\stack\ip\ble\profiles\find\findl\api;..\..\..\stack\ip\ble\profiles\find\findt\api;..\..\..\stack\ip\ble\profiles\glp\glpc\api;..\..\..\stack\ip\ble\profiles\glp\glps\api;..\..\..\stack\ip\ble\profiles\hogp\hogpbh\api;..\..\..\stack\ip\ble\profiles\hogp\hogpd\api;..\..\..\stack\ip\ble\profiles\hogp\hogprh\api;..\..\..\stack\ip\ble\profiles\hrp\hrpc\api;..\..\..\stack\ip\ble\profiles\hrp\hrps\api;..\..\..\stack\ip\ble\profiles\htp\htpc\api;..\..\..\stack\ip\ble\profiles\htp\htpt\api;..\..\..\stack\ip\ble\profiles\lan\lanc\api;..\..\..\stack\ip\ble\profiles\lan\lans\api;..\..\..\stack\ip\ble\profiles\pasp\paspc\api;..\..\..\stack\ip\ble\profiles\pasp\pasps\api;..\..\..\stack\ip\ble\profiles\prox\proxm\api;..\..\..\stack\ip\ble\profiles\prox\proxr\api;..\..\..\stack\ip\ble\profiles\rscp\rscpc\api;..\..\..\stack\ip\ble\profiles\rscp\rscps\api;..\..\..\stack\ip\ble\profiles\scpp\scppc\api;..\..\..\stack\ip\ble\profiles\scpp\scpps\api;..\..\..\stack\ip\ble\profiles\tip\tipc\api;..\..\..\stack\ip\ble\profiles\tip\tips\api;..\..\..\stack\ip\ble\profiles\uds\udsc\api;..\..\..\stack\ip\ble\profiles\uds\udss\api;..\..\..\stack\ip\ble\profiles\wscp\wscc\api;..\..\..\stack\ip\ble\profiles\wscp\wscs\api;..\..\..\stack\ip\ble\profiles\tspp\tspps\api;..\..\..\stack\ip\ble\profiles\tspp\tsppc\api;..\..\..\examples\common;..\..\..\stack\plf\hs6621\bb;..\..\..\stack\plf\hs6621\sc;..\src;..\..\..\stack\ip\ble\profiles\simple_server\api;..\..\..\stack\ip\ble\profiles\simple_server\src;..\..\..\third_party\FreeRTOS\include;..\..\..\third_party\FreeRTOS\portable\GCC\ARM_CM4F;..\..\..\third_party\CMSIS_RTOS2\Include;..\..\..\third_party\CMSIS_RTOS2\FreeRTOS\Include
  library: MicroLIB
  scatter file: ..\..\..\lib\keil\scatter_hs6621_flash_armclang.sct
  link misc: --via=..\..\..\lib\keil\armlink6.via
  group startup
    ../../../lib/keil/: startup_hs6621_flash.s
  group main
    ../src/: main.c ble_main.c
    ../../../hardware/peripheral/: retarget.c
  group app
    ../src/: app.c app_task.c app_simple_server.c
    ../../common/: app_adv.c app_sec.c
  group profile
    ../../../stack/ip/ble/profiles/simple_server/src/: simple_server.c simple_server_task.c
  group stack
    ../../../stack/plf/hs6621/rwip/: rwmem.c
  group FreeRTOS
    ../../../third_party/FreeRTOS/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../third_party/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../third_party/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group CMSIS_RTOS2
    ../../../third_party/CMSIS_RTOS2/FreeRTOS/Source/: cmsis_os2.c freertos_evr.c
    ../../../third_party/CMSIS_RTOS2/FreeRTOS/Source/ARM/: clib_arm.c
