# Keil uVision project ble_app_simple_server.uvproj, settings and files
target ble_app_simple_server_lvgl (6160000::V6.16::ARMCLANG)
  device: HS6621C.FPU HunterSun
  cpu: CLOCK(64000000) CPUTYPE("Cortex-M4") FPU2
  output: ble_app_simple_server
  AfterMake: fromelf.exe --bin --output "$L..\@L.bin" "#L"
  AfterMake: fromelf.exe -c --output "$L..\@L.dis" "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: CONFIG_LOG_OUTPUT CONFIG_RTOS CONFIG_LVGL
  c misc: @../../../lib/keil/armclang.via
  c include: ..\..\..\coroutine;..\..\..\include;..\..\..\main;..\..\..\hardware\sys;..\..\..\hardware\cmsis;..\..\..\hardware\cfg;..\..\..\hardware\peripheral;..\..\..\hardware\rw_port;..\..\..\hardware\patch;..\..\..\hardware\loader;..\..\..\hardware\mbr;..\..\..\stack\ip\ahi\api;..\..\..\stack\ip\hci\api;..\..\..\stack\ip\sch\api;..\..\..\stack\ip\em\api;..\..\..\stack\modules\aes\api;..\..\..\stack\modules\common\api;..\..\..\stack\modules\dbg\api;..\..\..\stack\modules\display\api;..\..\..\stack\modules\ecc_p256\api;..\..\..\stack\modules\h4tl\api;..\..\..\stack\modules\ke\api;..\..\..\stack\modules\nvds\api;..\..\..\stack\modules\rf\api;..\..\..\stack\modules\rwip\api;..\..\..\stack\modules\rwip\src;..\..\..\stack\plf\hs6621\arch;..\..\..\stack\plf\hs6621\reg;..\..\..\stack\ip\ble\hl\api;..\..\..\stack\ip\ble\hl\inc;..\..\..\stack\ip\ble\hl\src\rwble_hl;..\..\..\stack\ip\ble\ll\api;..\..\..\stack\ip\ble\ll\src;..\..\..\stack\ip\ble\mesh\api;..\..\..\stack\ip\ble\mesh\inc;..\..\..\stack\ip\ble\mesh\inc_al;..\..\..\stack\ip\ble\mesh\src\common\inc;..\..\..\stack\ip\ble\mesh\src\inc;..\..\..\stack\ip\ble\mesh\src\models;..\..\..\stack\ip\ble\mesh\src\models\inc;..\..\..\stack\ip\ble\mesh\src\models\src;..\..\..\stack\ip\ble\mesh\src\prf;..\..\..\stack\ip\ble\mesh\src\prf\inc;..\..\..\stack\ip\ble\profiles\anp;..\..\..\stack\ip\ble\profiles\bas;..\..\..\stack\ip\ble\profiles\bcs;..\..\..\stack\ip\ble\profiles\blp;..\..\..\stack\ip\ble\profiles\cpp;..\..\..\stack\ip\ble\profiles\cscp;..\..\..\stack\ip\ble\profiles\dis;..\..\..\stack\ip\ble\profiles\find;..\..\..\stack\ip\ble\profiles\glp;..\..\..\stack\ip\ble\profiles\hogp;..\..\..\stack\ip\ble\profiles\hrp;..\..\..\stack\ip\ble\profiles\htp;..\..\..\stack\ip\ble\profiles\lan;..\..\..\stack\ip\ble\profiles\pasp;..\..\..\stack\ip\ble\profiles\prox;..\..\..\stack\ip\ble\profiles\rscp;..\..\..\stack\ip\ble\profiles\scpp;..\..\..\stack\ip\ble\profiles\tip;..\..\..\stack\ip\ble\profiles\uds;..\..\..\stack\ip\ble\profiles\wscp;..\..\..\stack\ip\ble\profiles\anp\anpc\api;..\..\..\stack\ip\ble\profiles\anp\anps\api;..\..\..\stack\ip\ble\profiles\bas\basc\api;..\..\..\stack\ip\ble\profiles\bas\bass\api;..\..\..\stack\ip\ble\profiles\bcs\bcsc\api;..\..\..\stack\ip\ble\profiles\bcs\bcss\api;..\..\..\stack\ip\ble\profiles\blp\blpc\api;..\..\..\stack\ip\ble\profiles\blp\blps\api;..\..\..\stack\ip\ble\profiles\cpp\cppc\api;..\..\..\stack\ip\ble\profiles\cpp\cpps\api;..\..\..\stack\ip\ble\profiles\cscp\cscpc\api;..\..\..\stack\ip\ble\profiles\cscp\cscps\api;..\..\..\stack\ip\ble\profiles\dis\disc\api;..\..\..\stack\ip\ble\profiles\dis\diss\api;..\..\..\stack\ip\ble\profiles\find\findl\api;..\..\..\stack\ip\ble\profiles\find\findt\api;..\..\..\stack\ip\ble\profiles\glp\glpc\api;..\..\..\stack\ip\ble\profiles\glp\glps\api;..\..\..\stack\ip\ble\profiles\hogp\hogpbh\api;..\..\..\stack\ip\ble\profiles\hogp\hogpd\api;..\..\..\stack\ip\ble\profiles\hogp\hogprh\api;..\..\..\stack\ip\ble\profiles\hrp\hrpc\api;..\..\..\stack\ip\ble\profiles\hrp\hrps\api;..\..\..\stack\ip\ble\profiles\htp\htpc\api;..\..\..\stack\ip\ble\profiles\htp\htpt\api;..\..\..\stack\ip\ble\profiles\lan\lanc\api;..\..\..\stack\ip\ble\profiles\lan\lans\api;..\..\..\stack\ip\ble\profiles\pasp\paspc\api;..\..\..\stack\ip\ble\profiles\pasp\pasps\api;..\..\..\stack\ip\ble\profiles\prox\proxm\api;..\..\..\stack\ip\ble\profiles\prox\proxr\api;..\..\..\stack\ip\ble\profiles\rscp\rscpc\api;..\..\..\stack\ip\ble\profiles\rscp\rscps\api;..\..\..\stack\ip\ble\profiles\scpp\scppc\api;..\..\..\stack\ip\ble\profiles\scpp\scpps\api;..\..\..\stack\ip\ble\profiles\tip\tipc\api;..\..\..\stack\ip\ble\profiles\tip\tips\api;..\..\..\stack\ip\ble\profiles\uds\udsc\api;..\..\..\stack\ip\ble\profiles\uds\udss\api;..\..\..\stack\ip\ble\profiles\wscp\wscc\api;..\..\..\stack\ip\ble\profiles\wscp\wscs\api;..\..\..\stack\ip\ble\profiles\tspp\tspps\api;..\..\..\stack\ip\ble\profiles\tspp\tsppc\api;..\..\..\examples\common;..\..\..\stack\plf\hs6621\bb;..\..\..\stack\plf\hs6621\sc;..\src;..\..\..\stack\ip\ble\profiles\simple_server\api;..\..\..\stack\ip\ble\profiles\simple_server\src;..\..\..\third_party\FreeRTOS\include;..\..\..\third_party\FreeRTOS\portable\GCC\ARM_CM4F;..\..\..\third_party\lvgl-8.1.0\port;..\..\..\third_party\lvgl-8.1.0;..\..\..\third_party\lvgl-8.1.0\src;..\..\..\third_party\omfs;..\..\..\third_party\fs\omfs;..\..\..\third_party\fs\fatfs
  library: MicroLIB
  scatter file: ..\..\..\lib\keil\scatter_hs6621_flash_armclang.sct
  link misc: --via=..\..\..\lib\keil\armlink6.via
  group startup
    ../../../lib/keil/: startup_hs6621_flash.s
  group main
    ../src/: main.c ble_main.c ctp_hynitron_ext.c ctp_hynitron_iic.c lvgl_demo.c flash_outside.c glcd_gc9c01.c gif_asset.c om_gif_assets.c om_animation.c lv_om_animation.c
    ../../../hardware/peripheral/: retarget.c
    ../../peripheral/lcd/: example_lcd_serial.c
  group app
    ../src/: app.c app_task.c app_simple_server.c
    ../../common/: app_adv.c app_sec.c
  group profile
    ../../../stack/ip/ble/profiles/simple_server/src/: simple_server.c simple_server_task.c
  group stack
    ../../../stack/plf/hs6621/rwip/: rwmem.c
  group FreeRTOS
    ../../../third_party/FreeRTOS/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../third_party/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../third_party/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group lvgl
    ../../../third_party/lvgl-8.1.0/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../third_party/lvgl-8.1.0/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../third_party/lvgl-8.1.0/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../third_party/lvgl-8.1.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../third_party/lvgl-8.1.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../third_party/lvgl-8.1.0/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../../third_party/lvgl-8.1.0/src/extra/layouts/grid/: lv_grid.c
    ../../../third_party/lvgl-8.1.0/src/extra/layouts/flex/: lv_flex.c
    ../../../third_party/lvgl-8.1.0/src/extra/others/snapshot/: lv_snapshot.c
    ../../../third_party/lvgl-8.1.0/src/extra/themes/basic/: lv_theme_basic.c
    ../../../third_party/lvgl-8.1.0/src/extra/themes/default/: lv_theme_default.c
    ../../../third_party/lvgl-8.1.0/src/extra/themes/mono/: lv_theme_mono.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/animimg/: lv_animimg.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/chart/: lv_chart.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/led/: lv_led.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/list/: lv_list.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/meter/: lv_meter.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/span/: lv_span.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/spinner/: lv_spinner.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/tabview/: lv_tabview.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/win/: lv_win.c
    ../../../third_party/lvgl-8.1.0/port/: lv_port_disp.c lv_port_fs.c lv_port_hs662x.c lv_port_indev.c
    ../../../third_party/lvgl-8.1.0/src/extra/: lv_extra.c
    ../../../third_party/lvgl-8.1.0/src/extra/widgets/tileview/: lv_tileview.c
    ../../../third_party/lvgl-8.1.0/src/extra/libs/gif/: gifdec.c lv_gif.c
  group omfs
    ../../../third_party/fs/omfs/: fs.c fs_port.c
  group onmicro_optimizer
    ../src/: onmicro_pos.c lv_onmicro_decode.c
