# Keil uVision project ble_app_hid_keyboard.uvproj, settings and files
target ble_app_simple_server (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HS6621 HunterSun
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M4")
  output: ble_app_hid_keyboard +hex
  AfterMake: fromelf.exe --bin --output "$L..\@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CONFIG_LOG_OUTPUT
  c misc: --c99 --via=..\..\..\lib\keil\armcc.via
  c include: ..\..\..\coroutine;..\..\..\include;..\..\..\main;..\..\..\hardware\sys;..\..\..\hardware\cmsis;..\..\..\hardware\cfg;..\..\..\hardware\peripheral;..\..\..\hardware\rw_port;..\..\..\hardware\patch;..\..\..\hardware\loader;..\..\..\hardware\mbr;..\..\..\stack\ip\ahi\api;..\..\..\stack\ip\hci\api;..\..\..\stack\ip\sch\api;..\..\..\stack\ip\em\api;..\..\..\stack\modules\aes\api;..\..\..\stack\modules\common\api;..\..\..\stack\modules\dbg\api;..\..\..\stack\modules\display\api;..\..\..\stack\modules\ecc_p256\api;..\..\..\stack\modules\h4tl\api;..\..\..\stack\modules\ke\api;..\..\..\stack\modules\nvds\api;..\..\..\stack\modules\rf\api;..\..\..\stack\modules\rwip\api;..\..\..\stack\modules\rwip\src;..\..\..\stack\plf\hs6621\arch;..\..\..\stack\plf\hs6621\reg;..\..\..\stack\ip\ble\hl\api;..\..\..\stack\ip\ble\hl\inc;..\..\..\stack\ip\ble\hl\src\rwble_hl;..\..\..\stack\ip\ble\ll\api;..\..\..\stack\ip\ble\ll\src;..\..\..\stack\ip\ble\mesh\api;..\..\..\stack\ip\ble\mesh\inc;..\..\..\stack\ip\ble\mesh\inc_al;..\..\..\stack\ip\ble\mesh\src\common\inc;..\..\..\stack\ip\ble\mesh\src\inc;..\..\..\stack\ip\ble\mesh\src\models;..\..\..\stack\ip\ble\mesh\src\models\inc;..\..\..\stack\ip\ble\mesh\src\models\src;..\..\..\stack\ip\ble\mesh\src\prf;..\..\..\stack\ip\ble\mesh\src\prf\inc;..\..\..\stack\ip\ble\profiles\anp;..\..\..\stack\ip\ble\profiles\bas;..\..\..\stack\ip\ble\profiles\bcs;..\..\..\stack\ip\ble\profiles\blp;..\..\..\stack\ip\ble\profiles\cpp;..\..\..\stack\ip\ble\profiles\cscp;..\..\..\stack\ip\ble\profiles\dis;..\..\..\stack\ip\ble\profiles\find;..\..\..\stack\ip\ble\profiles\glp;..\..\..\stack\ip\ble\profiles\hogp;..\..\..\stack\ip\ble\profiles\hrp;..\..\..\stack\ip\ble\profiles\htp;..\..\..\stack\ip\ble\profiles\lan;..\..\..\stack\ip\ble\profiles\pasp;..\..\..\stack\ip\ble\profiles\prox;..\..\..\stack\ip\ble\profiles\rscp;..\..\..\stack\ip\ble\profiles\scpp;..\..\..\stack\ip\ble\profiles\tip;..\..\..\stack\ip\ble\profiles\uds;..\..\..\stack\ip\ble\profiles\wscp;..\..\..\stack\ip\ble\profiles\anp\anpc\api;..\..\..\stack\ip\ble\profiles\anp\anps\api;..\..\..\stack\ip\ble\profiles\bas\basc\api;..\..\..\stack\ip\ble\profiles\bas\bass\api;..\..\..\stack\ip\ble\profiles\bcs\bcsc\api;..\..\..\stack\ip\ble\profiles\bcs\bcss\api;..\..\..\stack\ip\ble\profiles\blp\blpc\api;..\..\..\stack\ip\ble\profiles\blp\blps\api;..\..\..\stack\ip\ble\profiles\cpp\cppc\api;..\..\..\stack\ip\ble\profiles\cpp\cpps\api;..\..\..\stack\ip\ble\profiles\cscp\cscpc\api;..\..\..\stack\ip\ble\profiles\cscp\cscps\api;..\..\..\stack\ip\ble\profiles\dis\disc\api;..\..\..\stack\ip\ble\profiles\dis\diss\api;..\..\..\stack\ip\ble\profiles\find\findl\api;..\..\..\stack\ip\ble\profiles\find\findt\api;..\..\..\stack\ip\ble\profiles\glp\glpc\api;..\..\..\stack\ip\ble\profiles\glp\glps\api;..\..\..\stack\ip\ble\profiles\hogp\hogpbh\api;..\..\..\stack\ip\ble\profiles\hogp\hogpd\api;..\..\..\stack\ip\ble\profiles\hogp\hogprh\api;..\..\..\stack\ip\ble\profiles\hrp\hrpc\api;..\..\..\stack\ip\ble\profiles\hrp\hrps\api;..\..\..\stack\ip\ble\profiles\htp\htpc\api;..\..\..\stack\ip\ble\profiles\htp\htpt\api;..\..\..\stack\ip\ble\profiles\lan\lanc\api;..\..\..\stack\ip\ble\profiles\lan\lans\api;..\..\..\stack\ip\ble\profiles\pasp\paspc\api;..\..\..\stack\ip\ble\profiles\pasp\pasps\api;..\..\..\stack\ip\ble\profiles\prox\proxm\api;..\..\..\stack\ip\ble\profiles\prox\proxr\api;..\..\..\stack\ip\ble\profiles\rscp\rscpc\api;..\..\..\stack\ip\ble\profiles\rscp\rscps\api;..\..\..\stack\ip\ble\profiles\scpp\scppc\api;..\..\..\stack\ip\ble\profiles\scpp\scpps\api;..\..\..\stack\ip\ble\profiles\tip\tipc\api;..\..\..\stack\ip\ble\profiles\tip\tips\api;..\..\..\stack\ip\ble\profiles\uds\udsc\api;..\..\..\stack\ip\ble\profiles\uds\udss\api;..\..\..\stack\ip\ble\profiles\wscp\wscc\api;..\..\..\stack\ip\ble\profiles\wscp\wscs\api;..\..\..\stack\ip\ble\profiles\tspp\tspps\api;..\..\..\stack\ip\ble\profiles\tspp\tsppc\api;..\..\..\examples\common;..\..\..\stack\plf\hs6621\bb;..\..\..\stack\plf\hs6621\sc;..\src;..\src\wechat;..\..\..\stack\ip\ble\profiles\simple_server\api;..\..\..\stack\ip\ble\profiles\simple_server\src;..\..\..\stack\ip\ble\profiles\wechat\src;..\..\..\stack\ip\ble\profiles\wechat\api;..\..\..\stack\ip\ble\profiles\bas\bass\src;..\..\..\stack\ip\ble\profiles\bas\bass\api;..\..\..\stack\ip\ble\profiles\dis\diss\src;..\..\..\stack\ip\ble\profiles\dis\diss\api;..\..\..\stack\ip\ble\profiles\hogp\hogpd\src;..\..\..\stack\ip\ble\profiles\hogp\hogpd\api;..\..\..\stack\ip\ble\profiles\tspp\tspps\src;..\..\..\stack\ip\ble\profiles\tspp\tspps\api;..\..\..\stack\ip\ble\profiles\tspp\;..\..\..\stack\ip\ble\profiles\ancs\src;..\..\..\stack\ip\ble\profiles\ancs\api;..\..\..\stack\ip\ble\profiles\nordic_dfu\src;..\..\..\stack\ip\ble\profiles\nordic_dfu\api;..\..\..\stack\ip\ble\profiles\nordic_dfu\src\nano-pb;..\..\..\stack\ip\ble\profiles\nordic_dfu\src\sha256;..\..\..\stack\ip\ble\profiles\nordic_dfu\src\uecc
  library: MicroLIB
  scatter file: ..\..\..\lib\keil\scatter_hs6621_flash.sct
  link misc: --via=..\..\..\lib\keil\armlink.via
  group startup
    ../../../lib/keil/: startup_hs6621_flash.s
  group main
    ../src/: main.c rwapp_config.h
    ../../../hardware/peripheral/: retarget.c
  group app
    ../src/: app.c app_task.c app_hid.c app_dis.c
    ../../common/: app_adv.c app_sec.c
  group profile
    ../../../stack/ip/ble/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    ../../../stack/ip/ble/profiles/dis/diss/src/: diss.c diss_task.c
  group stack
    ../../../stack/plf/hs6621/rwip/: rwmem.c
