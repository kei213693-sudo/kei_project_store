# Keil uVision project ble_app_rc.uvproj, settings and files
target ble_app_rc (6150000::V6.15::ARMCLANG)
  device: HS6621 HunterSun
  cpu: CLOCK(48000000) CPUTYPE("Cortex-M4")
  output: ble_app_rc
  AfterMake: fromelf.exe --bin --output "$L..\@L.bin" "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_LOG_OUTPUT
  c misc: @../../../lib/keil/armclang.via
  c include: ..\..\..\coroutine;..\..\..\include;..\..\..\main;..\..\..\hardware\sys;..\..\..\hardware\cmsis;..\..\..\hardware\cfg;..\..\..\hardware\peripheral;..\..\..\hardware\rw_port;..\..\..\hardware\patch;..\..\..\hardware\loader;..\..\..\hardware\mbr;..\..\..\stack\ip\ahi\api;..\..\..\stack\ip\hci\api;..\..\..\stack\ip\sch\api;..\..\..\stack\ip\em\api;..\..\..\stack\modules\aes\api;..\..\..\stack\modules\common\api;..\..\..\stack\modules\dbg\api;..\..\..\stack\modules\display\api;..\..\..\stack\modules\ecc_p256\api;..\..\..\stack\modules\h4tl\api;..\..\..\stack\modules\ke\api;..\..\..\stack\modules\nvds\api;..\..\..\stack\modules\rf\api;..\..\..\stack\modules\rwip\api;..\..\..\stack\modules\rwip\src;..\..\..\stack\plf\hs6621\arch;..\..\..\stack\plf\hs6621\reg;..\..\..\stack\ip\ble\hl\api;..\..\..\stack\ip\ble\hl\inc;..\..\..\stack\ip\ble\hl\src\rwble_hl;..\..\..\stack\ip\ble\ll\api;..\..\..\stack\ip\ble\ll\src;..\..\..\stack\ip\ble\mesh\api;..\..\..\stack\ip\ble\mesh\inc;..\..\..\stack\ip\ble\mesh\inc_al;..\..\..\stack\ip\ble\mesh\src\common\inc;..\..\..\stack\ip\ble\mesh\src\inc;..\..\..\stack\ip\ble\mesh\src\models;..\..\..\stack\ip\ble\mesh\src\models\inc;..\..\..\stack\ip\ble\mesh\src\models\src;..\..\..\stack\ip\ble\mesh\src\prf;..\..\..\stack\ip\ble\mesh\src\prf\inc;..\..\..\stack\ip\ble\profiles\anp;..\..\..\stack\ip\ble\profiles\bas;..\..\..\stack\ip\ble\profiles\bcs;..\..\..\stack\ip\ble\profiles\blp;..\..\..\stack\ip\ble\profiles\cpp;..\..\..\stack\ip\ble\profiles\cscp;..\..\..\stack\ip\ble\profiles\dis;..\..\..\stack\ip\ble\profiles\find;..\..\..\stack\ip\ble\profiles\glp;..\..\..\stack\ip\ble\profiles\hogp;..\..\..\stack\ip\ble\profiles\hrp;..\..\..\stack\ip\ble\profiles\htp;..\..\..\stack\ip\ble\profiles\lan;..\..\..\stack\ip\ble\profiles\pasp;..\..\..\stack\ip\ble\profiles\prox;..\..\..\stack\ip\ble\profiles\rscp;..\..\..\stack\ip\ble\profiles\scpp;..\..\..\stack\ip\ble\profiles\tip;..\..\..\stack\ip\ble\profiles\uds;..\..\..\stack\ip\ble\profiles\wscp;..\..\..\stack\ip\ble\profiles\anp\anpc\api;..\..\..\stack\ip\ble\profiles\anp\anps\api;..\..\..\stack\ip\ble\profiles\bas\basc\api;..\..\..\stack\ip\ble\profiles\bas\bass\api;..\..\..\stack\ip\ble\profiles\bcs\bcsc\api;..\..\..\stack\ip\ble\profiles\bcs\bcss\api;..\..\..\stack\ip\ble\profiles\blp\blpc\api;..\..\..\stack\ip\ble\profiles\blp\blps\api;..\..\..\stack\ip\ble\profiles\cpp\cppc\api;..\..\..\stack\ip\ble\profiles\cpp\cpps\api;..\..\..\stack\ip\ble\profiles\cscp\cscpc\api;..\..\..\stack\ip\ble\profiles\cscp\cscps\api;..\..\..\stack\ip\ble\profiles\dis\disc\api;..\..\..\stack\ip\ble\profiles\dis\diss\api;..\..\..\stack\ip\ble\profiles\find\findl\api;..\..\..\stack\ip\ble\profiles\find\findt\api;..\..\..\stack\ip\ble\profiles\glp\glpc\api;..\..\..\stack\ip\ble\profiles\glp\glps\api;..\..\..\stack\ip\ble\profiles\hogp\hogpbh\api;..\..\..\stack\ip\ble\profiles\hogp\hogpd\api;..\..\..\stack\ip\ble\profiles\hogp\hogprh\api;..\..\..\stack\ip\ble\profiles\hrp\hrpc\api;..\..\..\stack\ip\ble\profiles\hrp\hrps\api;..\..\..\stack\ip\ble\profiles\htp\htpc\api;..\..\..\stack\ip\ble\profiles\htp\htpt\api;..\..\..\stack\ip\ble\profiles\lan\lanc\api;..\..\..\stack\ip\ble\profiles\lan\lans\api;..\..\..\stack\ip\ble\profiles\pasp\paspc\api;..\..\..\stack\ip\ble\profiles\pasp\pasps\api;..\..\..\stack\ip\ble\profiles\prox\proxm\api;..\..\..\stack\ip\ble\profiles\prox\proxr\api;..\..\..\stack\ip\ble\profiles\rscp\rscpc\api;..\..\..\stack\ip\ble\profiles\rscp\rscps\api;..\..\..\stack\ip\ble\profiles\scpp\scppc\api;..\..\..\stack\ip\ble\profiles\scpp\scpps\api;..\..\..\stack\ip\ble\profiles\tip\tipc\api;..\..\..\stack\ip\ble\profiles\tip\tips\api;..\..\..\stack\ip\ble\profiles\uds\udsc\api;..\..\..\stack\ip\ble\profiles\uds\udss\api;..\..\..\stack\ip\ble\profiles\wscp\wscc\api;..\..\..\stack\ip\ble\profiles\wscp\wscs\api;..\..\..\stack\ip\ble\profiles\tspp\tspps\api;..\..\..\stack\ip\ble\profiles\tspp\tsppc\api;..\src;..\..\..\examples\common;..\..\..\stack\plf\hs6621\bb;..\..\..\stack\plf\hs6621\sc;..\..\..\stack\ip\ble\profiles\tspp;..\..\..\stack\ip\ble\profiles\tspp\tspps\api;..\..\..\stack\ip\ble\profiles\wechat\api;..\..\..\stack\ip\ble\profiles\dis\diss\api;..\..\..\stack\ip\ble\profiles\dis\diss\src;..\..\..\stack\ip\ble\profiles\bas\bass\src;..\..\..\stack\ip\ble\profiles\hogp\hogpd\src;..\..\..\stack\ip\ble\profiles\ancs\src;..\..\..\stack\ip\ble\profiles\atvv;..\..\..\stack\ip\ble\profiles\atvv\atvvs\api;..\..\common\sbc;..\..\common\sbc\encoder\include;..\..\..\stack\ip\ble\profiles\onmicro_dfu\api;..\..\..\stack\ip\ble\profiles\onmicro_dfu\src
  library: MicroLIB
  scatter file: ..\..\..\lib\keil\scatter_hs6621_flash_armclang.sct
  link misc: --via=..\..\..\lib\keil\armlink6.via
  group startup
    ../../../lib/keil/: startup_hs6621_flash.s
  group main
    ../src/: app.c main.c app_event.c m_audio.c m_key.c m_led.c m_uart.c key_process.c ir_dma.c
    ../../../hardware/peripheral/: retarget.c
  group stack
    ../../../stack/plf/hs6621/rwip/: rwmem.c
  group common
    ../../common/: app_adv.c app_privacy.c app_sec.c app_whl.c app_ancsc.c app_batt.c app_dis.c app_task.c app_tspp_server.c app_wechat.c app_atvv.c app_onmicro_dfu.c
    ../src/: app_hid.c
    ../../common/sbc/: libsbc.lib
  group profile
    ../../../stack/ip/ble/profiles/tspp/tspps/src/: tspps.c tspps_task.c
    ../../../stack/ip/ble/profiles/bas/bass/src/: bass.c bass_task.c
    ../../../stack/ip/ble/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../stack/ip/ble/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    ../../../stack/ip/ble/profiles/atvv/atvvs/src/: atvvs.c atvvs_task.c
    ../../../stack/ip/ble/profiles/onmicro_dfu/src/: dfu.c dfu_task.c onmicro_dfu.c onmicro_dfu_nvds.c public_key.c sha256.c uECC.c
  group webchat
    ../../common/wechat/: AES.c crc32.c epb.c epb_MmBp.c md5.c mpbledemo2.c wechat_util.c
  group codec
    ../src/: dvi_adpcm.c codec.lib ima_enc.c
