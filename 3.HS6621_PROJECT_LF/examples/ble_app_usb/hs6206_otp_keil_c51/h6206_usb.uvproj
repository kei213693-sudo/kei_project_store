# Keil uVision project h6206_usb.uvproj, settings and files
target hero_usb (MCS-51)
  device: HS6206 HunterSun
  cpu: IRAM(0-0xFF) CLOCK(16000000)  MOD517DP MDU_R515
  output: HS6206_USB +hex
  c flags: Optimize=9
  c define: HS6206_SPI,HS6206_USER_INTERFACE,HS6206_GPIO,HS6206_SPI_SLAVE
  c include: .\user
  link misc: REMOVEUNUSED
  group user
    ./: STARTUP_USR.A51
    ./user/: app_main.c HS6206_UART.c HS6206_Uti.c HS6206_GPIO.c HS6206_SPI.c HS6206_SFR.c HS6206_USB.c HS6206_Delay.c HS6206_RF.c
