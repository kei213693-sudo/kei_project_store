/********************************************************************                                                                  **
**  Device:     A7121
**  File:		Uti.c
**  Author:		JPH
**  Target:		Winbond W77LE58
********************************************************************/
#include "HS6206_Types.h"
#include "HS6206_Uti.h"
#include <intrins.h>

/**********************************************************
* Delay1ms:1.005ms
**********************************************************/
void Delay1ms(Uint16 time)
{
    unsigned int i;

    do
    {
        i=800;
        while(--i);
    }
    while(--time);
}

/**********************************************************
* Delay10us:12us
**********************************************************/
void Delay10us(Uint8 n)
{
	Uint8 i;
	while(n--)
	{
		for(i=0;i<6;i++)
		_nop_();
	}
}
/**********************************************************
* Delay10ms
**********************************************************/
//#ifdef DELAY_TIME_FUNCTION
#if 1
void Delay10ms(Uint8 n)
{
    Uint8 i,j;
    while(n--)
    {
        for(i=0;i<106;i++)
            for(j=0;j<250;j++);
    }
}
#endif
